/* SPDX-License-Identifier: Apache-2.0 */
#include <string.h>
#include "lib/crypto-algorithms/sha256.h"
#include "titan_ml_auto.h"

/* Only the reviewed Hand/Palm COP1 artifacts automatically share SRAM.
 * These hashes select a memory policy, never substitute model contents.
 * Other models keep the ordinary allocator. Explicit workspace=None also
 * keeps that path; explicit Workspace remains available to other reviewed graphs.
 * Refresh this list only after TFLM shared allocation and isolation review. */
static const struct {
    size_t bytes;
    uint8_t sha256[32];
} auto_models[] = {
    /* palm_detection_full_192 */
    {1307824, {0x3b, 0x9e, 0x46, 0x4d, 0xa5, 0xb1, 0xf4, 0x79, 0x8f, 0xef, 0x84, 0xca, 0x9e, 0xf1, 0xe6, 0x0d, 0x9f, 0x07, 0x74, 0x48, 0xa6, 0x02, 0x0f, 0x25, 0xd7, 0x8a, 0x73, 0x94, 0x99, 0x7f, 0x9c, 0x54}},
    /* hand_landmarks_full_224 */
    {2241168, {0x76, 0xc1, 0x80, 0x7d, 0xdb, 0x44, 0xf9, 0x9b, 0xca, 0xf8, 0x8a, 0xf1, 0xa2, 0x43, 0xd7, 0xd4, 0xb3, 0x8b, 0xc7, 0x64, 0x53, 0xdd, 0x51, 0x16, 0x53, 0xfd, 0x76, 0xc2, 0xfd, 0xe5, 0x96, 0xe1}},
    /* palm_detection_full_192_vela510_cop1 */
    {1310624, {0x40, 0x32, 0xd5, 0x97, 0xe3, 0xb9, 0x53, 0x2d, 0x90, 0x62, 0x34, 0xc6, 0x38, 0x21, 0xfb, 0xd7, 0x05, 0x3c, 0xf3, 0x70, 0x77, 0x91, 0x7b, 0xdc, 0x55, 0x98, 0xfa, 0x0b, 0x0f, 0xdc, 0xce, 0x39}},
};

int titan_ml_auto_model_supported(const uint8_t *data, size_t size)
{
    if (!data || !size) return 0;
    for (size_t i = 0; i < sizeof(auto_models) / sizeof(auto_models[0]); i++) {
        if (size != auto_models[i].bytes) continue;
        CRYAL_SHA256_CTX ctx;
        uint8_t digest[32];
        sha256_init(&ctx);
        sha256_update(&ctx, data, size);
        sha256_final(&ctx, digest);
        return memcmp(digest, auto_models[i].sha256, sizeof(digest)) == 0;
    }
    return 0;
}
